# Keil uVision project q1_with_bonus.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: q1_with_bonus +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: q1_with_bonus.a51
